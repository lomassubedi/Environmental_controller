# Keil uVision project ENV_CTRL_F051_REV0.uvproj, settings and files
target STM32F051R8T6 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: ENV_CTRL_F051_REV0
  c flags: Optim=3 oTime=1
  c define: USE_STDPERIPH_DRIVER, STM32F051, STM32F0_DISCOVERY, TMP_FAHRENHEIT
  c include: ..\src;..\src\APP;..\src\STM32F0-Discovery;..\..\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\outputs\ENV_CTRL_F051_REV0.sct
  group USER
    ../src/: main.c
  group APP
    ../src/APP/: flags_timers.c
  group STARTUP
    ../src/startup/: startup_stm32f0xx.s
  group SYSTEM
    ../src/: stm32f0xx_it.c system_stm32f0xx.c
  group DRIVER
    ../../STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c
