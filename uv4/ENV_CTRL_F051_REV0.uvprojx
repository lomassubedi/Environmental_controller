# Keil uVision project ENV_CTRL_F051_REV0.uvprojx, settings and files
target STM32F051R8T6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ENV_CTRL_F051_REV0
  c flags: Optim=3 oTime=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F051, STM32F0_DISCOVERY, TMP_FAHRENHEIT
  c include: ..\src;..\src\APP;..\src\MODBUS;..\src\STM32F0-Discovery;..\..\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\outputs\ENV_CTRL_F051_REV0.sct
  group USER
    ../src/: main.c
  group BOARD
    ../src/STM32F0-Discovery/: stm32f0_discovery.c
  group APP
    ../src/APP/: flags_timers.c
  group STARTUP
    ../src/startup/: startup_stm32f0xx.s
  group SYSTEM
    ../src/: stm32f0xx_it.c system_stm32f0xx.c
  group DRIVER
    ../../STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_tim.c
  group MODBUS
    ../src/MODBUS/: modbus_slave.c mbcrc.c
software components: CMSIS:CORE 5.0.2
